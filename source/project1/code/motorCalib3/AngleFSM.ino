void Angle_FSM_update() {
  // Uses the Arduino Wire and AS5600 library.
  // ANGLE_FSM_update(): AS5600 angle readout as an FSM.
// - Publishes angle (degrees) into global 'sig_angle_deg'.
// - Modes: TRIGGERED (between external triggers) or FREE-RUN (fixed period).

  // -------- Config --------
  const bool         TRIGGERED          = false;   // true: wait for external trigger (sig_trigger change)
  const unsigned int FREE_RUN_PERIOD_MS = 100;    // used only if TRIGGERED == false

  // -------- States --------
  const byte INIT    = 0;
  const byte WAIT    = 1;
  const byte MEASURE = 2;

  // -------- Locals --------
  static byte          state       = INIT;
  static unsigned long lastTrigger = 0;     // copy of sig_trigger when last consumed
  static unsigned long lastMs      = 0;     // time of last measurement

  static AS5600        as5600;  //create object

  unsigned long nowMs = millis();

  switch (state) {

    case INIT: 
      Wire.begin();
      as5600.begin();          // proceed regardless; user can handle errors elsewhere
      //sig_angle_deg = 0.0;     // global output (declare elsewhere)
      lastTrigger   = sig_trigger;
      lastMs        = nowMs;
      state         = WAIT;
      break;

    case WAIT: 
      if (TRIGGERED) {
        if (sig_trigger != lastTrigger) {
          state = MEASURE;     // external trigger arrived
        }
      } else {
        if (nowMs - lastMs >= FREE_RUN_PERIOD_MS) {
          state = MEASURE;     // periodic sampling
        }
      }
      break;

    case MEASURE:
      sig_angle_deg = (float)as5600.readAngle()*0.0879; //0.0879=360/4096;  // degrees [0..360)
      lastMs = nowMs;
      if (TRIGGERED) lastTrigger = sig_trigger; // consume trigger
      state = WAIT;
      break;
  }//switch
}
